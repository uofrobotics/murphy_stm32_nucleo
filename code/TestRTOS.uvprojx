# Keil uVision project TestRTOS.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TestRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-cast-align -Wno-unused-parameter -Wno-vla -Wno-declaration-after-statement -Wno-extra-semi-stmt -Wno-padded -Wno-missing-noreturn -Wno-covered-switch-default -Wno-invalid-utf8 -Wno-newline-eof -Wno-strict-prototypes -Wno-missing-variable-declarations
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c io_control.c io_control.h usart.c usart.h CLI.c CLI.h test.c test.h indicator.c indicator.h sabertooth.c sabertooth.h ultrasonic.c ultrasonic.h jetson_comms.c jetson_comms.h
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.5.0, CMSIS:RTOS:FreeRTOS 10.4.6, CMSIS:RTOS2:FreeRTOS 10.4.6, Device:Startup 1.0.0
